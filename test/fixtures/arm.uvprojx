# Keil uVision project arm.uvprojx, settings and files
target Debug (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  output: demo
  c flags: Optim=4
  c define: USE_HAL_DRIVER, STM32F103xB
  c include: .\Core\Inc;.\Drivers\CMSIS\Include
  group Application
    ./Core/Src/: main.c stm32f1xx_it.c
  group Generated
    ./Core/Src/: missing.c
target Release (ARM-ADS)
  device: STM32F103C8
  output: demo
  c define: NDEBUG
  c include: .\Core\Inc
  group left out of the first target's files
    ./Core/Src/: main.c missing.c stm32f1xx_it.c
