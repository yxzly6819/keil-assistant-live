# Keil uVision project c51.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  c define: DEBUG=1
  c include: .\inc
  group Source Group 1
    ./src/: main.c STARTUP.A51
